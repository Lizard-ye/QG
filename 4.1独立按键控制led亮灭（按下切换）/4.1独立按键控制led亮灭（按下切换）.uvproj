# Keil uVision project 4.1独立按键控制led亮灭（按下切换）.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 4.1独立按键控制led亮灭（按下切换） +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 4.c
